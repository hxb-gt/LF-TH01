# Keil uVision project CA51F5_Touch.uvproj, settings and files
target CA51F5 (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51fx +hex
  c flags: Optimize=9
  link misc: REMOVEUNUSED
  group Sources
    ./: main.c interrupt.c
    ./Library/Sources/: delay.c system_clock.c uart.c wdt.c
  group TS_lib
    ./TS_Lib/Sources/: debug.c ts_api.c ts_service.LIB
  group Lib
    ./Library/Lib/: STARTUP.A51
  group app
    ./app/: heater.c heater.h display.c menu.c
